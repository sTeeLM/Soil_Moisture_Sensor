# Keil uVision project Soil_Moisture_Sensor.uvproj, settings and files
target Debug (MCS-51)
  device: STC8G1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000)
  output: Soil_Moisture_Sensor.bin +hex
  c flags: Optimize=9
  c define: __SOL_DEBUG__
  c include: .\state_machine
  group system
    ./: STARTUP.A51 main.c system.c delay.c com.c debug.c task.c clock.c sm.c gpio.c power.c moisture.c bt.c button.c adc.c cext.c i2c.c oled.c tdc.c oled_font.c oled_ext.c oled_icon.c
  group state machines
    ./state_machine/: sm_main.c
